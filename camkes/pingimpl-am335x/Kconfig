## camkes/pingimpl-am335x/Kconfig
```kconfig
config APP_PINGIMPL
    bool "Generated CAmkES PingImpl application"
    default n
        help
            Application generated from AADL
```
